# Inventory skeleton only; unbuilt and not product-cleared.
SUMMARY = "fast-cdr isolated PC simulation dependency"
LICENSE = "Apache-2.0"
SRC_URI = "git://github.com/eProsima/Fast-CDR.git;protocol=https;nobranch=1"
# Evaluated source revision/tag: 757d5e422253568c487ad97c22e44680fc1ddbaf
# TODO: pin SRCREV, LIC_FILES_CHKSUM, build integration and transitive licences.
# PC binary package versions are recorded in pixi.lock; use meta-ros for ROS packaging.
