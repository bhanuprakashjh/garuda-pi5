# Inventory skeleton only; unbuilt and not product-cleared.
SUMMARY = "ros2-bench isolated PC simulation dependency"
LICENSE = "Apache-2.0 & BSD-3-Clause"
SRC_URI = "git://github.com/ros2/ros2.git;protocol=https;nobranch=1"
# TODO: pin SRCREV, LIC_FILES_CHKSUM, build integration and transitive licences.
# PC binary package versions are recorded in pixi.lock; use meta-ros for ROS packaging.
