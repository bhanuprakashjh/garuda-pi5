# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "yolox-pc visual simulation dependency"
LICENSE = "Apache-2.0"
SRC_URI = "https://github.com/opencv/opencv_zoo"
# Evaluated tag/revision: 48b10fa505aeb51fbd127fc60a5c660040e823b7
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
