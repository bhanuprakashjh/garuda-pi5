# Inventory skeleton only; unbuilt and not product-cleared.
SUMMARY = "fast-dds isolated PC simulation dependency"
LICENSE = "Apache-2.0"
SRC_URI = "git://github.com/eProsima/Fast-DDS.git;protocol=https;nobranch=1"
# Evaluated source revision/tag: adc13326bdb4b9df05405102238ea205d1974478
# TODO: pin SRCREV, LIC_FILES_CHKSUM, build integration and transitive licences.
# PC binary package versions are recorded in pixi.lock; use meta-ros for ROS packaging.
