# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "gazebo-actor visual simulation dependency"
LICENSE = "CC-BY-4.0"
SRC_URI = "https://fuel.gazebosim.org/1.0/Mingfei/models/actor/1"
# Evaluated tag/revision: 1
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
