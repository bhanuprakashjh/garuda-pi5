# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "numpy visual simulation dependency"
LICENSE = "BSD-3-Clause"
SRC_URI = "https://github.com/numpy/numpy"
# Evaluated tag/revision: v1.26.4
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
