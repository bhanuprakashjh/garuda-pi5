# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "pillow visual simulation dependency"
LICENSE = "HPND"
SRC_URI = "https://github.com/python-pillow/Pillow"
# Evaluated tag/revision: 11.3.0
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
