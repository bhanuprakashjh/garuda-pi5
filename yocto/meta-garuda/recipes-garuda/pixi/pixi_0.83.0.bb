# Inventory skeleton only; unbuilt and not product-cleared.
SUMMARY = "pixi isolated PC simulation dependency"
LICENSE = "BSD-3-Clause"
SRC_URI = "git://github.com/prefix-dev/pixi.git;protocol=https;nobranch=1"
# Evaluated source revision/tag: v0.83.0
# TODO: pin SRCREV, LIC_FILES_CHKSUM, build integration and transitive licences.
# PC binary package versions are recorded in pixi.lock; use meta-ros for ROS packaging.
