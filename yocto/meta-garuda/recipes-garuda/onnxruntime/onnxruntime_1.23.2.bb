# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "onnxruntime visual simulation dependency"
LICENSE = "MIT"
SRC_URI = "https://github.com/microsoft/onnxruntime"
# Evaluated tag/revision: v1.23.2
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
