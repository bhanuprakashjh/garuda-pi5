# Inventory skeleton only; unbuilt, PC evaluation, not a product recipe.
SUMMARY = "opencv-python visual simulation dependency"
LICENSE = "Apache-2.0"
SRC_URI = "https://github.com/opencv/opencv-python"
# Evaluated tag/revision: 4.10.0.84
# TODO: archive or git fetch URI, checksum, LIC_FILES_CHKSUM and target integration.
# See models/yolox_pc.md for provenance and transitive dependency licences.
