# Inventory skeleton only; unbuilt and not product-cleared.
SUMMARY = "cyclonedds isolated PC simulation dependency"
LICENSE = "EPL-2.0 | EDL-1.0"
SRC_URI = "git://github.com/eclipse-cyclonedds/cyclonedds.git;protocol=https;nobranch=1"
# TODO: pin SRCREV, LIC_FILES_CHKSUM, build integration and transitive licences.
# PC binary package versions are recorded in pixi.lock; use meta-ros for ROS packaging.
