# UNBUILT documentation stub: desktop release tool, not a target image dependency.
SUMMARY = "PyInstaller desktop testing-release packager"
LICENSE = "GPL-2.0-only-with-bootloader-exception & Apache-2.0"
SRC_URI = "https://files.pythonhosted.org/packages/source/p/pyinstaller/pyinstaller-${PV}.tar.gz"
# TODO before any BitBake build: verify archive/LIC_FILES_CHKSUM, native class,
# exact SPDX exception spelling and build dependencies. Not product-cleared.
